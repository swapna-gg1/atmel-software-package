# IAR project flash_loader-extram_sama5d2-generic.ewp, settings and files
configuration sama5d2-generic_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D2; CONFIG_CHIP_SAMA5D27; CONFIG_PACKAGE_289PIN; CONFIG_BOARD_SAMA5D2_GENERIC; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO4; CONFIG_HAVE_PIO4_SECURE; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_GMAC_QUEUES; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_MPDDRC_DDR3; CONFIG_HAVE_MPDDRC_LPDDR3; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_DIFF_INPUT; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_PMC_AUDIO_CLOCK; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_H32MXDIV; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_DMA; CONFIG_HAVE_PWMC_SPREAD_SPECTRUM; CONFIG_HAVE_PWMC_EXTERNAL_TRIGGER; CONFIG_HAVE_PWMC_FAULT_PROT_HIZ; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_TIMER_POLLING; CONFIG_HAVE_SFRBU; CONFIG_HAVE_L2CC; CONFIG_HAVE_SAIC; CONFIG_HAVE_XDMAC; CONFIG_HAVE_XDMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SECUMOD; CONFIG_HAVE_SFC; CONFIG_HAVE_PWMC; CONFIG_HAVE_SECURE_MATRIX; CONFIG_HAVE_DDR2_MT47H128M8; CONFIG_HAVE_DDR2_MT47H64M16; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_DDR2_W971GG6SB; CONFIG_HAVE_DDR2_W972GG6KB; CONFIG_HAVE_DDR2_W9712G6KB; CONFIG_HAVE_DDR2_W9751G6KB; CONFIG_HAVE_LPDDR2_MT42L128M16; CONFIG_HAVE_LPDDR2_AD220032D; CONFIG_HAVE_LPDDR2_AD210032D; CONFIG_HAVE_DDR3_MT41K128M16; CONFIG_HAVE_LPDDR3_EDF8164A3MA; CONFIG_HAVE_RSTC_CONFIGURABLE_USER_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_TC_DMA_MODE; CONFIG_HAVE_RTC_CALIBRATION; CONFIG_HAVE_RTC_MODE_PERSIAN; CONFIG_HAVE_RTC_MODE_UTC; CONFIG_HAVE_RTC_TAMPER; CONFIG_HAVE_SHDWC; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_L2CACHE; CONFIG_HAVE_UART; CONFIG_HAVE_SERIALD_UART; CONFIG_HAVE_USART; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_SERIALD_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\flash_loaders\applets\common; ..\..\..\flash_loaders\applets\common\framework2; ..\..\..\arch; ..\..\..\utils; ..\..\..\target\common; ..\..\..\target\sama5d2; ..\..\..\drivers; ..\..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flash_loader-extram.bin
  postbuild: cmd /c "copy /Y "build\sama5d2-generic\sram\Exe\flash_loader-extram.out" "..\..\sama5d2-generic\flash_loader-extram.out"
  ILINK.IlinkOutputFile: flash_loader-extram.out
  ILINK.IlinkIcfFile: ..\..\..\flash_loaders\applets\common\sama5d2\sram.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: extram_flash_loader.c
    ../common/framework2/: flash_loader.c flash_loader_asm.s
    ../common/: interface.c
  group arch
    ../../../arch/arm/: fault_handlers.c l1cache_cp15.c mmu_cp15.c mutex.c
  group drivers
    ../../../drivers/irq/: aic5.c irq.c
    ../../../drivers/peripherals/: bus.c flexcom.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c sfrbu.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../../drivers/mm/: cache.c l2cache_l2cc.c
    ../../../drivers/serial/: console.c seriald.c uart.c usart.c usartd.c
    ../../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../../drivers/nvm/nand/: nfc.c
    ../../../drivers/gpio/: pio4.c piobu.c
    ../../../drivers/security/: secumod.c
    ../../../drivers/nvm/: sfc.c
  group target
    ../../../target/common/: board_console.c board_timer.c chip_common.c
    ../../../target/sama5d2/: board_sama5d2-generic.c board_support.c chip.c
  group utils
    ../../../utils/: callback.c intmath.c rand.c syscalls.c timer.c trace.c
