<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/flash_loader-extram_sama5d2-generic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/flash_loader-extram_sam9x60-generic.ewp</path>
  </project>
</workspace>
