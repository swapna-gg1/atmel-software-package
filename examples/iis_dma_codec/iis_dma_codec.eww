<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/iis_dma_codec_sam9x60-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/iis_dma_codec_sama5d2-xplained.ewp</path>
  </project>
</workspace>
