# IAR project lcd_sam9x60-ek.ewp, settings and files
configuration sam9x60-ek_sram (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9X60; CONFIG_CHIP_SAM9X60; CONFIG_BOARD_SAM9X60_EK; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SDRAMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_SCKC; CONFIG_HAVE_NFD0_ON_D16; CONFIG_HAVE_XDMAC; CONFIG_HAVE_LCD; CONFIG_HAVE_LCDC; CONFIG_HAVE_LCDC_OVR1; CONFIG_HAVE_LCDC_OVR2; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_W972GG6KB; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_RTT; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_OTPC; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_USART; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_DWDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sam9x60; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lcd.bin
  ILINK.IlinkOutputFile: lcd.out
  ILINK.IlinkIcfFile: ..\..\target\sam9x60\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sam9x60-ek_ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9X60; CONFIG_CHIP_SAM9X60; CONFIG_BOARD_SAM9X60_EK; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SDRAMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_SCKC; CONFIG_HAVE_NFD0_ON_D16; CONFIG_HAVE_XDMAC; CONFIG_HAVE_LCD; CONFIG_HAVE_LCDC; CONFIG_HAVE_LCDC_OVR1; CONFIG_HAVE_LCDC_OVR2; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_W972GG6KB; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_RTT; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_OTPC; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_USART; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_DWDT
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ..\..\target\sam9x60\toolchain\iar\ddram.icf
configuration sam9x60-ek_qspi0 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 5
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_QSPI0; CONFIG_ARCH_ARMV5TE; CONFIG_ARCH_ARM; CONFIG_SOC_SAM9X60; CONFIG_CHIP_SAM9X60; CONFIG_BOARD_SAM9X60_EK; CONFIG_HAVE_AIC5; CONFIG_HAVE_FLEXCOM; CONFIG_HAVE_PIO3; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SDRAMC; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_DATA_PATH; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_ADC_LOW_RES; CONFIG_HAVE_PMC_FAST_STARTUP; CONFIG_HAVE_PMC_GENERATED_CLOCKS; CONFIG_HAVE_SCKC; CONFIG_HAVE_NFD0_ON_D16; CONFIG_HAVE_XDMAC; CONFIG_HAVE_LCD; CONFIG_HAVE_LCDC; CONFIG_HAVE_LCDC_OVR1; CONFIG_HAVE_LCDC_OVR2; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_W972GG6KB; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_RTT; CONFIG_HAVE_SHDWC; CONFIG_HAVE_LED; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_OTPC; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_USART; CONFIG_HAVE_USART_FIFO; CONFIG_HAVE_DWDT
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ..\..\target\sam9x60\toolchain\iar\qspi0.icf
  group (top)
    ./: font.c lcd_draw.c lcd_font.c main.c
  group arch
    ../../arch/arm/: fault_handlers.c l1cache_cp15.c mmu_cp15.c mutex.c
  group drivers
    ../../drivers/irq/: aic5.c irq.c
    ../../drivers/peripherals/: bus.c flexcom.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c rtt.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/mm/: cache.c
    ../../drivers/serial/: console.c dbgu.c seriald.c usart.c usartd.c
    ../../drivers/extram/: ddram.c mpddrc.c sdram.c sdramc.c smc.c
    ../../drivers/dma/: dma.c dma_xdmac.c xdmac.c
    ../../drivers/display/: lcdc.c
    ../../drivers/led/: led.c
    ../../drivers/nvm/otp/: otpc.c
    ../../drivers/gpio/: pio3.c
  group target
    ../../target/common/: board_console.c board_lcd.c board_led.c board_timer.c chip_common.c
    ../../target/sam9x60/: board_sam9x60-ek.c board_support.c chip.c
    ../../target/sam9x60/toolchain/iar/: cstartup.s
  group utils
    ../../utils/: callback.c intmath.c rand.c syscalls.c timer.c trace.c
