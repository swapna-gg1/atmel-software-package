<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/pwm_sama5d27-som1-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm_sam9x60-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/pwm_sama5d2-xplained.ewp</path>
  </project>
</workspace>
