# IAR project ssc_dma_audio_sama5d3-ek.ewp, settings and files
configuration sama5d3-ek_sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D36 Atmel ATSAMA5D36
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_SRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D3; CONFIG_CHIP_SAMA5D36; CONFIG_BOARD_SAMA5D3_EK; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_DIFF_INPUT; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_PLLA_CHARGE_PUMP; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_DMAC; CONFIG_HAVE_DMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_AUDIO; CONFIG_HAVE_SSC; CONFIG_HAVE_AUDIO_WM8904; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\arch; ..\..\utils; ..\..\target\common; ..\..\target\sama5d3; ..\..\drivers; ..\..\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssc_dma_audio.bin
  ILINK.IlinkOutputFile: ssc_dma_audio.out
  ILINK.IlinkIcfFile: ..\..\target\sama5d3\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sama5d3-ek_ddram (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SOFTPACK_VERSION="2.17"; TRACE_LEVEL=5; VARIANT_DDRAM; CONFIG_ARCH_ARMV7A; CONFIG_ARCH_ARM; CONFIG_SOC_SAMA5D3; CONFIG_CHIP_SAMA5D36; CONFIG_BOARD_SAMA5D3_EK; CONFIG_HAVE_AIC5; CONFIG_HAVE_PIO3; CONFIG_HAVE_NFC; CONFIG_HAVE_PIT; CONFIG_HAVE_SMC; CONFIG_HAVE_SMC_SCRAMBLING; CONFIG_HAVE_MPDDRC; CONFIG_HAVE_MPDDRC_IO_CALIBRATION; CONFIG_HAVE_MPDDRC_DDR2; CONFIG_HAVE_MPDDRC_LPDDR2; CONFIG_HAVE_ADC_SETTLING_TIME; CONFIG_HAVE_ADC_INPUT_OFFSET; CONFIG_HAVE_ADC_DIFF_INPUT; CONFIG_HAVE_ADC_SEQ_R2; CONFIG_HAVE_PMC_PLLADIV2; CONFIG_HAVE_PMC_PLLA_CHARGE_PUMP; CONFIG_HAVE_PMC_UPLL_BIAS; CONFIG_HAVE_PMC_PERIPH_DIV; CONFIG_HAVE_SCKC; CONFIG_HAVE_PWMC_STEPPER_MOTOR; CONFIG_HAVE_PWMC_CMP_UNIT; CONFIG_HAVE_PWMC_SYNC_MODE; CONFIG_HAVE_PWMC_OOV; CONFIG_HAVE_PWMC_FMODE; CONFIG_HAVE_PWMC_WP; CONFIG_HAVE_PWMC_DTIME; CONFIG_HAVE_PWMC_ELINE; CONFIG_HAVE_DMAC; CONFIG_HAVE_DMAC_DATA_WIDTH_DWORD; CONFIG_HAVE_SMD; CONFIG_HAVE_PWMC; CONFIG_HAVE_DDR2_MT47H128M16; CONFIG_HAVE_RSTC_EXTERNAL_RESET; CONFIG_HAVE_RSTC_INDEPENDENT_RESET; CONFIG_HAVE_TC_FAULT_MODE; CONFIG_HAVE_AUDIO; CONFIG_HAVE_SSC; CONFIG_HAVE_AUDIO_WM8904; CONFIG_HAVE_SHDWC; CONFIG_HAVE_TWI; CONFIG_HAVE_I2C_BUS; CONFIG_HAVE_MMU; CONFIG_HAVE_L1CACHE; CONFIG_HAVE_DBGU; CONFIG_HAVE_SERIALD_DBGU; CONFIG_HAVE_UART; CONFIG_HAVE_USART
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ..\..\target\sama5d3\toolchain\iar\ddram.icf
  group (top)
    ./: main.c
  group arch
    ../../arch/arm/: fault_handlers.c l1cache_cp15.c mmu_cp15.c mutex.c
  group drivers
    ../../drivers/irq/: aic5.c irq.c
    ../../drivers/audio/: audio_device.c ssc.c wm8904.c
    ../../drivers/peripherals/: bus.c matrix.c pit.c pmc.c pwmc.c rstc.c rtc.c shdwc.c slowclock_sckc.c tc.c tcd.c wdt.c
    ../../drivers/mm/: cache.c
    ../../drivers/serial/: console.c dbgu.c seriald.c uart.c usart.c usartd.c
    ../../drivers/extram/: ddram.c mpddrc.c smc.c
    ../../drivers/dma/: dma.c dma_dmac.c dmac.c
    ../../drivers/nvm/nand/: nfc.c
    ../../drivers/gpio/: pio3.c
    ../../drivers/i2c/: twi.c twid.c
  group target
    ../../target/common/: board_audio.c board_console.c board_timer.c board_twi.c chip_common.c
    ../../target/sama5d3/: board_sama5d3-ek.c board_support.c chip.c
    ../../target/sama5d3/toolchain/iar/: cstartup.s
  group utils
    ../../utils/: callback.c intmath.c rand.c syscalls.c timer.c trace.c wav.c
