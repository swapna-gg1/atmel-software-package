<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ssc_dma_audio_sama5d3-ek.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ssc_dma_audio_sama5d2-xplained.ewp</path>
    </project>
    <batchBuild />
</workspace>
